SUMMARY = " FastAPI framework, high performance, easy to learn, fast to code, ready for production "
HOMEPAGE = "https://fastapi.tiangolo.com"
LICENSE = "MIT"
SECTION = "devel/python"
LIC_FILES_CHKSUM = "file://LICENSE;md5=95792ff3fe8e11aa49ceb247e66e4810"

SRC_URI[sha256sum] = "023a0f5bd2c8b2609014d3bba1e14a1d7df96c6abea0a73070621c9862b9a4de"

inherit pypi python_hatchling
